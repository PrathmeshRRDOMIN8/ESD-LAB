	AREA RESET, DATA, READONLY
	EXPORT __Vectors

__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R0,= SRC
	LDR R1,= DST
    LDR R1,[R1]	
	MOV R2, #10
	LDR R4,= N
	LDR R5, [R4]
LOOP  LDR R3, [R0], #4
	TEQ R3, R5
	BEQ EXIT
	SUB R2, #1
	TEQ R2, #0
	BNE LOOP
	
EXIT ADD R1,#1
STOP B STOP
	
N DCD 0xEEEEDDDD
SRC DCD 0x14256363, 0x1343F241, 0xFFFFFFFF, 0xEEEEDDDD, 0xCCCCBBBB, 0x14256363, 0x1343F241, 0xFFFFFFFF, 0xEEEEDDDD, 0xCCCCBBBB
	AREA DATASEG, DATA, READWRITE
DST DCD 0
	END