	AREA RESET, DATA, READONLY
	EXPORT __Vectors

__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R0, = SRC
	LDR R1,[R0]
	MOV R2,#1
	BL FACT
	LDR R5,=RES
	STR R2,[R5]
STOP B STOP

FACT CMP R1,#1
	BEQ EXIT
	PUSH {R1,LR}
	SUB R1,#1
	BL FACT
	
EXIT POP{R1,LR}
	MUL R2,R1
	BX LR
	
SRC DCD 0x4
	AREA DATASEG, DATA, READWRITE
RES DCD 0
	END